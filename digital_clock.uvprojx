# Keil uVision project digital_clock.uvprojx, settings and files
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: digital_clock +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F30X_HD DEBUG
  c include: .\GD32F30x_standard_peripheral\Include;.\CMSIS\GD\GD32F30x\Include;.\CMSIS;..\Software;.\driver;.\driver\Include;.\common\easy_log;.\common\system_timer;.\common\system_timer;.\common\terminal_com
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: main.c gd32f30x_it.c
  group Peripherals
    ./GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group CMSIS
    ./CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Startup
    ./CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s startup_gd32f30x_hd.s startup_gd32f30x_xd.s
  group drivers
    ./driver/Source/: driver_rcc.c driver_timer.c driver_uart.c driver_i2c.c
    ./driver/: chip_resource.c
  group common
    ./common/easy_log/: elog.c elog_buf.c elog_port.c elog_utils.c
    ./common/system_timer/: system_timer.c
    ./common/terminal_com/: terminal_com.c
